# Repository DAlexis/caustic-lasertag-system

File README.md:

# Caustic Lasertag System
For Russian description scroll down the page.

Описание на русском --- внизу страницы.

## Overview
Caustic project is a full-featured outdoor and indoor wireless lasertag system. It consists of principial schemes, PCBs and firmware for devices used in lasertag game. For now, system consists of:
  - Player's gun
  - Player's sensor to detect shoots
  - Smart control point for 'capture the point' game and some other things
  - Bluetooth bridge that provide interconnection between your smartphone and all the devices in game near bridge
  - Android application (currently alpha state) to control the game and change settings

Caustic Lasertag System licensed under GPLv3. Third party code used in project may be licensed under other licences, see corresponding files and comments in the sources. Copyright 2016, see AUTHORS file.

## Project structure
Here is a directories description:
  - `Android/` --- Android application to control the game and change settings 
  - `cpp-sources/` --- MCU firmware. Here:
     - `bootloader-usb/` is a reference to https://github.com/DAlexis/stm32-usb-bootloader --- bootloader that supports cardreader functionality and flash controller from file `flash.bin`
     - `universal-device/` --- universal firmware for any Caustic LTS device.  
  - `Docs/` --- some datasheets and useful documents for project
  - `media/` --- sounds and its raws. Most of them were get from https://www.freesound.org/
  - `schematic/` --- electic schemes, PCBs and gerbers made with KiCad
  - `tools/` --- some scripts to simplify primitive jobs
  - `sdcards/` --- samples of devices' SD cards containment

## How to build firmware
Now only Linux OS supported to build Caustic LTS firmware, but I use `CMake` so add Windows support should not be a very complicated task.

You need to install `cmake`, `arm-none-eabi-gcc` compiler **with** `arm-none-eabi-newlib` and `arm-none-eabi-binutils` installed, and installation dirs should be in `$PATH`. Simply installation from your distro's repository usually enough. To flash the MCU with ST-link programmer you should install `stlink` utility. Then:

  - Clone this repository:
    
    `git clone https://github.com/DAlexis/caustic-lasertag-system.git`
  - Go to `cpp-sources` directory:
    
    `cd caustic-lasertag-system/cpp-sources`
  - Download git submodule containing bootloader:
    
    `git submodule init && git submodule update`
  - Run `build.sh` for debug build and `build.sh release` for release one

Then, to program the board:
  - Connect ST-link programmer to the board and to yout PC's USB
  - To flash main firmware run
  
    `flash-universal-device.sh`
  - To flash bootloader run
  
    `flash-bootloader.sh`
    To flash release version add `release` parameter to both scripts

    **NOTE:** flashing bootloader means removing previous firmware. To flash main program after flashing bootloader you should rename `universal-device.bin` to `flash.bin` and copy it to sd-card's root, then reboot device.

  - Then, copy proper sh-card containment to your device's sd-card. For example, for gun you should copy all files and dirs from `sdcards/rifle` to gun's sd-card.

# Лазертаг-система Caustic
Caustic --- это полноценная беспроводная система для внеаренного и аренного лазертага. Проект содержит принципиальные схемы, печатные платы, прошивки микроконтроллера и другой необходимый код. На данный момент, система включает:
  - Оружие игрока
  - Датчики попадания ("головная повязка") для игрока
  - Умная контрольная точка для игры в "захват точки", поддерживающая другие вспомогательные функции
  - Bluetooth-мост, позволяющий подключать смартфон одновременно к любому количеству устройств системы
  - Приложение для Android (на данный момент в альфа-версии) для управления игрой и настройки игровых устройств

Система Caustic лицензирована под GPLv3. Система включает код тертьих лиц, который может быть лицензирован под другими лицензиями. Copyright 2016, Алексей Булатов. 

## Структура проекта
Проект устроен следующим образом:
  - `Android/` --- Приложение для Android 
  - `cpp-sources/` --- Прошивка для контроллера
     - `bootloader-usb/` --- ссылка на https://github.com/DAlexis/stm32-usb-bootloader --- загрузчик, превращающий устройство в кардридер, если при запуске оно подключено к компьютеру по USB. Прошивает контроллер из файла `flash.bin`
     - `universal-device/` --- универсальная прошивка для любого устройства системы Caustic
  - `Docs/` --- даташиты, документация и некоторые полезные документы
  - `media/` --- звуки и их исходники. по большей части, взяты с https://www.freesound.org/
  - `schematic/` --- схемы, печатные платы, герберы, сделанные в KiCad
  - `tools/` --- некоторые скрипты, упрощающие некоторые простые действия
  - `sdcards/` --- содержимое SD-карт для устройств разных типов

## Как собрать прошивку и загрузчик
На данный момент поддерживается сборка только из-под Linux, однако проект использует `CMake`, так что добавить поддержку Windows не составит труда.

У вас дожен быть установлен `cmake`, компилятор `arm-none-eabi-gcc`, **включая** `arm-none-eabi-newlib` и `arm-none-eabi-binutils`. Компилятор должен быть доступен в `$PATH`. Обычно, достаточно просто установить соответствующие пакеты из репозитория вашего дистрибутива. Для прошивки нужен программатор ST-link и соответствующая утилита `stlink`. 

Загрузчик **не является** обязательным.

Итак, для установки:

  - Склонируйте этот репозиторий:
    
    `git clone https://github.com/DAlexis/caustic-lasertag-system.git`
  - Перейдите в папку `cpp-sources`:
    
    `cd caustic-lasertag-system/cpp-sources`
  - Инициализируйте и загрузите подмодуль, содержащий загрузчик:
    
    `git submodule init && git submodule update`
  - Запустите `build.sh` для сборки в режиме build, или `build.sh release` для сборки в release

Теперь, чтобы запрограммировать устройство:
  - Подключите программатор к плате устройства и к компьютеру. Включите питание устройства
  - Чтобы прошить основную программу, наберите
  
    `flash-universal-device.sh`
  - Чтобы прошить загрузчик:
  
    `flash-bootloader.sh`
    Чтобы прошить программу, собранную в release, добавьте параметр `release` к каждому из скриптов.

    **ВАЖНО:** При прошивке загрузчика стирается всё, что до этого было зашито в контроллер. Поэтому после прошивки загрузчика нужно сделать следующее: переименовать `universal-device.bin` в `flash.bin` и положить в корень sd-карты (это можно сделать, просто подключив устройство по USB к компьютеру). После перезагрузки устройства загрузчик автоматически зальет прошивку в контроллер. Вообще говоря, можно вообще не использовать загрузчик.

  - Скопируйте необходимое содержимое на sd-карту. Например, если устройство --- это оружие игрока, скопируйте всё содержимое `sdcards/rifle` на карту устройства. Именно так прошивка поймёт, "кем быть".

## KiCad design schematic/rifle/monolith-v1/rifle-mono-v1.kicad_pcb

Parts:
C1, C12, C13, C16: 100uF; TantalC_SizeB_EIA-3528_Reflow
C2, C3, C4, C5, C8, C9, C17: 0.1; C_0805
C6, C7: 20pF; C_0805
C10, C11: 0.1uF; C_0805
C14: 4.7uF; C_0805
C18: 0.015uF; C_0805
C19: 0.47uF; C_0805
D1: Chrg; LED_0805
D2: DBG; LED_0805
P1: MICROSD-SDIO-CD; MICROSD-CD-112J-WH
P2: SWD; Pin_Header_Straight_1x04
P3: G B Vcc; Pin_Header_Straight_1x03
P4: NRF24L01; NRF24L01-mini
P5: USB_A; USB_B
P6: S_A_M1_M2; Pin_Header_Straight_1x04
P7: DEBUG_TX; Pin_Header_Straight_1x02
P8: Fire; Pin_Header_Straight_1x01
P9: Reload; Pin_Header_Straight_1x01
P10: RC522; Socket_Strip_Straight_1x08
P11: Speaker1; Pin_Header_Straight_1x02
P12: Speaker2; Pin_Header_Straight_1x02
P13, P14: I2C display; Socket_Strip_Straight_1x04
P15: FLASH; Pin_Header_Straight_1x01
P16: VIBRO; Pin_Header_Straight_1x01
P17: IR_LED; Pin_Header_Straight_1x02
P18: USB_OTG; USB_Micro-B
P19: GND; Pin_Header_Straight_1x03
P20: Laser; Pin_Header_Straight_1x01_Pitch2.00mm
Q1: IRLML6402; SOT-23
Q2, Q3, Q4, Q5, Q6, Q7: IRLML2502; SOT-23
R1, R2, R3, R4, R5: 47k; R_0805
R6, R7, R13, R14, R15, R17, R19, R20, R22, R23: 10k; R_0805
R8: 1.5k; R_0805
R9, R11: 470; R_0805
R10: 2k; R_0805
R12: 100; R_0805
R16: lev1; R_0805
R18: lev2; R_0805
R21: lev3; R_0805
R24: lev4; R_0805
R25, R26: 3.3k; R_0805
U1: STM32F103RE; LQFP-64_10x10mm_Pitch0.5mm
U2: USBLC6-4; SOT-23-6
U3: MCP73831; SOT-23-5
U4: NCP551; SOT-23-5
U5: PAM8403; SO-16-N
Y1: 8MHz; Crystal_HC49-U_Vertical

Connections:
+3.3VDAC: C16.1, R12.1, U1.13 (VDDA)
+3V3: C1.1, C2.1, C3.1, C4.1, C5.1, C9.1, C13.1, P1.4 (Vdd), P4.2 (VCC), P10.8, R1.1, R2.1, R3.1, R4.1, R5.1, R8.2, R12.2, U1.19 (VDD), U1.32 (VDD), U1.48 (VDD), U1.64 (VDD), U4.5 (Out)
+CHARGE: C14.1, P3.2, U3.3 (Vbat)
/FIRE_FLASH: Q4.1 (G), R19.1, U1.17 (USART2_RX/TIM5_CH4/ADC123_IN3/TIM2_CH4/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)
/IR_CH1: P20.1, Q2.1 (G), R15.1, U1.22 (SPI1_MISO/TIM8_BKIN/ADC12_IN6/TIM3_CH1/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)
/IR_CH2: Q3.1 (G), R17.1, U1.23 (SPI1_MOSI/TIM8_CH1N/ADC12_IN7/TIM3_CH2/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)
/IR_CH3: Q5.1 (G), R20.1, U1.26 (ADC12_IN8/TIM3_CH3/TIM8_CH2N/PB0)
/IR_CH4: Q7.1 (G), R23.1, U1.27 (ADC12_IN9/TIM3_CH4/TIM8_CH3N/PB1)
/NRF_CE: P4.3 (CE), U1.59 (I2C1_SDA/TIM4_CH2/PB7)
/NRF_CSN: P4.4 (CSN), U1.33 (SPI2_NSS/I2S2_WS/I2C2_SMBA/USART3_CK/TI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)
/NRF_IRQ: P4.8 (IRQ), U1.61 (TIM4_CH3/SDIO_D4/PB8)
/NRF_MISO: P4.7 (MISO), U1.35 (SPI2_MISO/TIM1_CH2N/USART3_RTS/PB14)
/NRF_MOSI: P4.6 (MOSI), U1.36 (SPI2_MOSI/I2S2_SD/TIM1_CH3N/PB15)
/NRF_SCK: P4.5 (SCK), U1.34 (SPI2_SCK/I2S2_CK/USART3_CTS/TIM1_CH1N/P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)
/RC522_IRQ: P10.5, U1.28 (BOOT1/PB2)
/RC522_MISO: P10.4, U1.56 (NJTRST/SPI3_MISO/PB4)
/RC522_MOSI: P10.3, U1.57 (I2C1_SMBA/SPI3_MOSI/I2S3_CD/PB5)
/RC522_RST: P10.7, U1.58 (I2C1_SCL/TIM4_CH1/PB6)
/RC522_SCK: P10.2, U1.55 (JTDO/SPI3_SCK/I2S3_CK/PB3)
/RC522_SDA: P10.1, U1.50 (JTDI/SPI3_NSS/I2S3_WS/PA15)
/SDIO_0: P1.7 (DAT0), R2.2, U1.39 (PC8/TIM8_CH3/SDIO_D0)
/SDIO_1: P1.8 (DAT1/nIRQ), R1.2, U1.40 (PC9/TIM8_CH4/SDIO_D1)
/SDIO_2: P1.1 (DAT2), R5.2, U1.51 (PC10/UART4_TX/SDIO_D2)
/SDIO_3: P1.2 (DAT3), R4.2, U1.52 (PC11/UART4_RX/SDIO_D3)
/SDIO_CLK: P1.5 (CLK), U1.53 (PC12/UART5_TX/SDIO_CK)
/SDIO_CMD: P1.3 (CMD), R3.2, U1.54 (PD2/TIM3_ETR/UART5_RX/SDIO_CMD)
/VIBRO_ENG: Q6.1 (G), R22.1, U1.16 (USART2_TX/TIM5_CH3/ADC123_IN2/TIM2_CH3/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)
DAC_OUT: R13.2, U1.20 (SPI1_NSS/USART2_CK/DAC_OUT1/ADC12_IN4/P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)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C16.2, C17.2, C18.1, P1.6 (GND), P2.1, P3.1, P4.1 (GND), P5.4 (GND), P7.1, P10.6, P13.1, P14.1, P18.5 (GND), P19.1, P19.2, P19.3, Q1.1 (G), Q2.2 (S), Q3.2 (S), Q4.2 (S), Q5.2 (S), Q6.2 (S), Q7.2 (S), R6.2, R10.2, R15.2, R17.2, R19.2, R20.2, R22.2, R23.2, U1.12 (VSSA), U1.18 (VSS), U1.31 (VSS), U1.47 (VSS), U1.63 (VSS), U2.2 (GND), U3.2 (Vss), U4.2 (GND), U5.2 (PGND), U5.11 (GND), U5.15 (PGND)
I2C_SCL: P13.3, P14.3, R26.2, U1.29 (I2C2_SCL/USART3_TX/PB10)
I2C_SDA: P13.4, P14.4, R25.2, U1.30 (I2C2_SDA/USART3_RX/PB11)
NRST: P2.2, U1.7 (~NRST)
unnamed: C6.1, U1.5 (PD0/OSC_IN), Y1.2
unnamed: C7.1, U1.6 (PD1/OSC_OUT), Y1.1
unnamed: C17.1, U5.8 (Vref)
unnamed: C18.2, C19.2, R13.1
unnamed: C19.1, R14.2
unnamed: D1.1 (K), R9.2
unnamed: D1.2 (A), P5.1 (VBUS), P18.1 (VBUS), U2.5 (Vbus), U3.4 (Vdd)
unnamed: D2.2 (A), R11.2
unnamed: P3.3, Q1.3 (D)
unnamed: P6.1, U1.8 (PC0/ADC123_IN10)
unnamed: P6.2, U1.9 (PC1/ADC123_IN11)
unnamed: P6.3, U1.10 (PC2/ADC123_IN12)
unnamed: P6.4, U1.11 (PC3/ADC123_IN13)
unnamed: P8.1, U1.14 (WKUP/USART2_CTS/ADC123_IN0/TIM2_CH1_ETR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)
unnamed: P9.1, U1.15 (USART2_RTS/ADC123_IN1/TIM5_CH2/TIM2_CH2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)
unnamed: P11.1, U5.3 (-OutLeft)
unnamed: P11.2, U5.1 (+OutLeft)
unnamed: P12.1, U5.14 (-OutRight)
unnamed: P12.2, U5.16 (+OutRight)
unnamed: P15.1, Q4.3 (D)
unnamed: P16.1, Q6.3 (D)
unnamed: P17.2, R16.1, R18.1, R21.1, R24.1
unnamed: Q2.3 (D), R16.2
unnamed: Q3.3 (D), R18.2
unnamed: Q5.3 (D), R21.2
unnamed: Q7.3 (D), R24.2
unnamed: R9.1, U3.1 (STAT)
unnamed: R10.1, U3.5 (PROG)
unnamed: R14.1, U5.7 (InLeft), U5.10 (InRight)
SWCLK: P2.4, U1.49 (JTCK/SWCLK/PA14)
SWDIO: P2.3, U1.46 (JTMS/SWDIO/PA13)
UART_DBG_TX: D2.1 (K), P7.2, U1.42 (USART1_TX/TIM1_CH2/PA9)
USBDM: P5.2 (D-), P18.2 (D-), U1.44 (USART1_CTS/USBDM/CAN_RX/TIM1_CH4/PA11), U2.4 (I/O3)
USBDP: P5.3 (D+), P18.3 (D+), R8.1, U1.45 (USART1_RTS/USBDP/CAN_TX/TIM1_ETR/PA11), U2.6 (I/O4)
VCC: C8.2, C11.1, C12.1, P13.2, P14.2, P17.1, Q1.2 (S), R7.1, R11.1, R25.1, R26.1, U4.1 (In), U4.3 (Enable), U5.4 (PVDD), U5.5 (~Mute), U5.6 (VDD), U5.12 (~Shutdown), U5.13 (PVDD)
VCC_ADC: C10.1, R6.1, R7.2, U1.24 (PC4/ADC12_IN14)

Board: 2 copper layers, 88.8 x 30.0 mm, 83 parts (40 on the bottom side), 68 nets.

Other parts of the board:
wholes: WHOLES-LINE-3; wholes-line-3
wholes#2, wholes#3, wholes#4: WHOLES-LINE-3; wholes-line-3

## KiCad design schematic/sensor-module/sensor-tube/sensor-tube.kicad_pcb

Parts:
P1: SENSOR_CONNECTOR
R1: 200
R2, R3: 150
U1: RGB-LED
U2: TSOP4856

Connections:
GND: P1.1 (GND), U2.2 (GND); also elsewhere on the board
unnamed 1: P1.2 (+Vcc), R1.1, R2.1, R3.1; also elsewhere on the board
unnamed 2: P1.3 (+3.3), U2.3 (V+); also elsewhere on the board
unnamed 3: P1.4 (Signal), U2.1 (OUT); also elsewhere on the board
unnamed 4: P1.5 (R), U1.3 (R-); also elsewhere on the board
unnamed 5: P1.6 (G), U1.2 (G-); also elsewhere on the board
unnamed 6: P1.7 (B), U1.1 (B-); also elsewhere on the board
unnamed: R1.2, U1.6 (B+)
unnamed: R2.2, U1.5 (G+)
unnamed: R3.2, U1.4 (R+)

Board: 2 copper layers, 27.7 x 8.5 mm, 7 parts (0 on the bottom side), 10 nets.

Other parts of the board:
P2: SENSOR_CONNECTOR; caustic-sensors-tube-connector

Their connections:
GND: P2.1; also elsewhere on the board
unnamed 1: P2.2; also elsewhere on the board
unnamed 2: P2.3; also elsewhere on the board
unnamed 3: P2.4; also elsewhere on the board
unnamed 4: P2.5; also elsewhere on the board
unnamed 5: P2.6; also elsewhere on the board
unnamed 6: P2.7; also elsewhere on the board

## KiCad design schematic/universal-device/universal-v1-rev1/universal-dev-v1-r1.kicad_pcb

Parts:
C1: 4.7uF
C2: 0.47uF
C3: 0.015uF
C4, C5, C6: 0.1uF
C7, C10, C12: CP1
C8: 470uF
C9, C11: 1uF
D1: LED
FB1: FILTER
JP1: JUMPER
K1, K2: CONN_3
K3: TSOP
P1: USB
P2: MCU1
P3: Buttons
P4: VCC
P5: Speaker2
P7: UART1
P8: EXTENSION-CONNECTOR
P9: MOSFET
P10: MCU2
P12: NRF24L01
P13: IR_LED
Q1: MOSFET_P
Q2, Q3, Q5, Q6, Q7, Q8: MOS_N
Q4: MOSFET_N
R1, R3, R4, R5, R8, R9, R12, R13, R14, R15: 10k
R2: 470
R6, R7: R
R10: 1.5k
R11: 2k
U1: PAM8403
U2: NCP551
U3: USBLC6-4
U4: MCP73831

Connections:
+3.3V: C10.1, C12.1, K3.3, P2.2, P8.7, P12.2 (VCC), R10.2, U2.5 (Out)
GND: C3.2, C4.1, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, JP1.2, K1.1, K1.2 (PM), K1.3, K2.1, K3.2 (PM), P1.1, P2.1, P7.1, P8.6, Q1.G, Q2.S, Q3.S, Q4.S, Q5.S, Q6.S, Q7.S, Q8.S, R5.2, R8.2, R9.2, R11.2, R12.2, R13.2, R14.2, R15.2, U1.2 (PGND), U1.9 (NC), U1.11 (GND), U1.15 (PGND), U2.2 (GND), U3.2 (GND), U4.2 (Vss)
unnamed: C2.2, R3.1
unnamed: P2.6, P3.3
unnamed: P2.5, P3.2
unnamed: P2.4, P3.1
unnamed: P5.2 (PM), U1.16 (+OutRight)
unnamed: P5.1, U1.14 (-OutRight)
unnamed: P2.7, P3.4
unnamed: R3.2, U1.10 (InRight)
unnamed: P2.12, R1.2
unnamed: P2.14, Q2.G, R12.1
unnamed: P13.1, R6.2, R7.2
unnamed: Q3.D, R7.1
unnamed: Q2.D, R6.1
unnamed: C2.1, C3.1, R1.1
unnamed: P10.19, P12.8 (IRQ)
unnamed: C4.2, U1.8 (Vref)
unnamed: D1.1 (A), P1.4, U3.5 (Vbus), U4.4 (Vdd)
unnamed: C1.1, K2.2 (PM), U4.3 (Vbat)
unnamed: C1.2, R11.1, U4.5 (PROG)
unnamed: R2.2, U4.1 (STAT)
unnamed: D1.2 (K), R2.1
unnamed: K2.3, Q1.D
unnamed: P2.15, Q3.G, R13.1
unnamed: C8.1, C9.1, C11.1, FB1.1, U1.4 (PVDD), U1.5 (~Mute), U1.6 (VDD), U1.12 (~Shutdown), U1.13 (PVDD)
unnamed: P9.1, Q8.D
unnamed: P9.2, Q7.D
unnamed: P9.3, Q6.D
unnamed: P9.4, Q5.D
unnamed: P2.18, Q6.G, R9.1
unnamed: P10.7, Q4.G
unnamed: P2.17, Q5.G, R8.1
unnamed: P2.20, Q8.G, R15.1
unnamed: K3.1, P2.8
unnamed: P2.19, Q7.G, R14.1
unnamed: P8.5, P10.17
unnamed: P8.1, P10.13
unnamed: P8.2, P10.14
unnamed: P8.3, P10.16
unnamed: P8.4, P10.15
unnamed: P10.18, P12.3 (CE)
unnamed: P10.3, P12.4 (CSN)
unnamed: P10.4, P12.5 (SCK)
unnamed: P10.6, P12.6 (MOSI)
unnamed: P10.5, P12.7 (MISO)
unnamed: JP1.1, P12.1 (GND), Q4.D
unnamed: P8.10, P10.2
unnamed: P8.9, P10.1
unnamed: P8.8, P10.20
unnamed: P7.2 (PM), P10.9
unnamed: P1.2, P10.11, U3.6 (I/O4)
unnamed: C6.1, P2.16, R4.2, R5.1
unnamed: P1.3, P10.12, R10.1, U3.4 (I/O3)
VCC: C5.1, C7.1, FB1.2, P4.1, P4.2 (PM), P13.2 (PM), Q1.S, R4.1, U2.1 (In), U2.3 (Enable)

Board: 2 copper layers, 61.3 x 34.3 mm, 60 parts (26 on the bottom side), 55 nets.

Other parts of the board:
1PIN, 1PIN#2, 1PIN#3, 1PIN#4: P***; 1pin
