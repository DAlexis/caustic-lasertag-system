# Repository DAlexis/caustic-lasertag-system (continued)

## KiCad design schematic/bridge/bluetooth-bridge/bluetooth-bridge.kicad_pcb (continued)

Board: 2 copper layers, 47.5 x 42.2 mm, 36 parts (11 on the bottom side), 36 nets.

Other parts of the board:
1PIN, 1PIN#2: P***; 1pin

## Code that names these connections

File cpp-sources/CubeMX-project/new-universal-device/new-universal-device.ioc (part):

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Mcu.Name=STM32F103R(C-D-E)Tx
Mcu.Package=LQFP64
Mcu.UserName=STM32F103RETx
PA10.Mode=Asynchronous
PA10.Signal=USART1_RX
PA11.Mode=Device
PA11.Signal=USB_DM
PA12.Mode=Device
PA12.Signal=USB_DP
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA2.Mode=Asynchronous
PA2.Signal=USART2_TX
PA3.Mode=Asynchronous
PA3.Signal=USART2_RX
PA4.Signal=COMP_DAC1_group
PA5.Signal=GPXTI5
PA6.Signal=S_TIM3_CH1
PA7.Signal=S_TIM3_CH2
PA9.Mode=Asynchronous
PA9.Signal=USART1_TX
PB0.Signal=S_TIM3_CH3
PB10.Mode=Half_duplex(single_wire_mode)
PB10.Signal=USART3_TX
PB13.Mode=Full_Duplex_Master
PB13.Signal=SPI2_SCK
PB14.Mode=Full_Duplex_Master
PB14.Signal=SPI2_MISO
PB15.Mode=Full_Duplex_Master
PB15.Signal=SPI2_MOSI
PB3.Mode=Full_Duplex_Master
PB3.Signal=SPI3_SCK
PB4.Mode=Full_Duplex_Master
PB4.Signal=SPI3_MISO
PB5.Mode=Full_Duplex_Master
PB5.Signal=SPI3_MOSI
PB8.Signal=GPXTI8
PC0.Signal=GPXTI0
PC1.Signal=GPXTI1
PC10.Mode=SD_4_bits_Wide_bus
PC10.Signal=SDIO_D2
PC11.Mode=SD_4_bits_Wide_bus
PC11.Signal=SDIO_D3
PC12.Mode=SD_4_bits_Wide_bus
PC12.Signal=SDIO_CK
PC13-TAMPER-RTC.Signal=GPXTI13
PC14-OSC32_IN.Signal=GPXTI14
PC15-OSC32_OUT.Signal=GPXTI15
PC2.Signal=GPXTI2
PC3.Signal=GPXTI3
PC4.Signal=ADCx_IN14
PC6.Signal=GPXTI6
PC7.Signal=GPXTI7
PC8.Mode=SD_4_bits_Wide_bus
PC8.Signal=SDIO_D0
PC9.Mode=SD_4_bits_Wide_bus
PC9.Signal=SDIO_D1
PD0-OSC_IN.Mode=HSE-External-Oscillator
PD0-OSC_IN.Signal=RCC_OSC_IN
PD1-OSC_OUT.Mode=HSE-External-Oscillator
PD1-OSC_OUT.Signal=RCC_OSC_OUT
PD2.Mode=SD_4_bits_Wide_bus
PD2.Signal=SDIO_CMD
RCC.SYSCLKFreq_VALUE=72000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=new-universal-device

## Commit log (part)

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2015-06-14 Cube hal without lock works
2015-06-18 File access fixed: root cause if low stack size
2015-06-19 Fix for rifle damage; task and mutex wrappers done
2015-06-25 NRF enabled, std periph added to project for quickly migration
2015-06-26 Att2 project deleted
2015-07-01 MT2 receiver enabled, but some refactoring needed
2015-07-26 Kill zones reenabled (not tested), shock delay head sensor side implemented (not tested). State saver fix - WIP
2015-07-30 Stdperiph works in critical section
2015-07-31 Nothing, but eclipse updated to Mars
2015-08-23 Description doc added
2015-08-24 Rifle wav enabling in process
2015-08-25 Sound mixing support added
2015-08-26 Audio bug, th knock after respawn sound fixed
2015-08-28 Rifle support pinout from file now; all pins RESET at start added to prevent accidents with LEDS and other
2015-08-30 Cooperative tasks pool added and replaced deferred task runner
2015-08-31 No heartbeat sound added
2015-09-04 rcsp parameters and funcitons types now in one file
2015-09-08 RCSP system refactoring. Modem and aggregator are now disconnected
2015-09-10 fix for prev commit: new files added
2015-09-18 Bluetooth bridge seems implemented, android tool beginned
2015-09-19 Implementation in process
2015-09-21 Stream serialization/deserialization works
2015-09-26 Some android works
2015-09-27 Respawn all command works
2015-09-29 Stream abstraction added
2015-09-30 Preference headers generation in runtime
2015-10-01 Parameters get/set works
2015-10-02 Rewriting of device anager
2015-10-03 Devices list fragment and new activity created, list with custom elements works
2015-10-05 Parameters editing works with some stragme manipulation at list adapters getView
2015-10-08 New UI in process, some things done
2015-10-09 Simple controls menu added, tests moved to new system
2015-10-09 Full descriptions and serializers set and test coverage
2015-10-11 Values of PAM8403 resistors added
2015-10-16 Revert button works, not equal sign not tested
2015-10-17 Device selection to edit is more smart now
2015-10-23 IR diode power configuration added
2015-10-25 Float variables support; fix for case when parameter iu element was not rendered till Apply pressed; other parameters added
2015-10-31 Some receiver refactoring, fix for rifle disabling after death
2015-11-04 10x2 pin array centering fix
2015-11-14 New head sensor board; some RTC and ADC code
2015-11-16 MCU module rev2 done
2015-11-25 rifle shield sended
2015-11-28 Android app refactoring: factories for serializers removed
2015-11-29 Wide screen support beginned
2015-12-04 Bug with sudden disabling of radio module fixed. Added workaround: probably some (?) modules have a bug: tx done flag and IRQ does not set sometimes
2015-12-07 bootloader as a separated project works
2015-12-08 Changing vector table works: no only fix in new CMSIS define needed; Standalone bootloader beginned
2015-12-10 HAL removed from loader
2015-12-10 Flash and file hash checking works
2015-12-11 hash cheching added
2015-12-14 New bootloader with HAL and USB beginned
2015-12-15 Cardreader works
2015-12-31 hw-specific code now only in hw dir
2016-01-03 RTC should work without quartz
2016-01-05 Minor code change
2016-01-05 IR TV receiver seems working
2016-01-10 New receiver seems working
2016-01-13 Async settings loading added
2016-01-22 Head and rifle boards done
2016-01-24 Group made
2016-01-31 Fix for prev commit
2016-01-31 State saver fixed; playerId opcode commented out (playerMT2id is enough); base stats saver seems correctly saving stats to file
2016-02-12 Some fork under bluetooth bridge stabilization
2016-03-26 fix: Some untracked files added
2016-03-26 Some commands treated as respawn now
2016-03-31 SPI seems fixed for rifle when shooting
2016-04-04 LCD 5110 works
2016-04-05 RFID class ported from arduino works
2016-04-07 Deregistration added but not tested, SPI quick reconfiguration support
2016-04-13 Some rifle pcb improvements: led is 1206, tants are type E, hw rf swith added
2016-04-22 Fix for lcd/rfid wires
2016-05-27 Round sensord with universal board groupped
2016-06-01 Weapon change fixed: stack overflow. HS addr is restorable now.
2016-06-30 damager notification fixed. Network timings changed. Timeouted packages removing improved
2016-07-05 Some old grouped boards with incorrect TSOP added
2016-07-05 Main project builds with cmake
2016-07-07 Project restructured for cmake
2016-07-10 Initial job for smart point
2016-07-10 Universal connector pinout class, .ods doc
2016-07-12 Snart point can switch
2016-07-19 State saver active for smart point; contrast setting added
2016-07-19 Lecense headers added to .hpp and .cpp files for universal-device; AUTHORS and LICENSE files added
2016-07-28 Eclipse artifacts removed
2016-08-18 Orphography fixed
2016-08-19 ScopedTag class removed
2016-08-31 Android refactoring: settings editor context moved to non-ui-specific part but not used yet
2016-09-01 Android: packages structure changed again (simply renaiming); old files removed
2016-09-04 [PCB] Fix for prev commit
2016-09-09 Old MilesTag transmitter removed, new interaces are used
2016-09-15 [Android] Gradle update, theme fix
2016-09-17 [Android] Bluetooth device autoconnection. Start activity only connect via bluetooth
2016-09-20 [Android] Bluetooth connection interface improved. Autorun MainControlsActivity only once. Fixed disconnection when pressing back key on devices list activity.
2016-09-24 [android] Android studio updated to 2.2
2016-09-26 [firmware] NRF24 communication via IRadioPhysical - radio module can be replaced now
2016-10-02 [PCB] Monolith head sensor board for fixed box beginned; [android] small IDE config change
2016-10-04 [PCB] Monolith HS beginned, initial jobs: board cuts, footprints added to list
2016-10-10 [PCB] Errors check in progress
2016-10-11 [PCB] Plots for head sensor for G431 added
2016-10-12 [Android] Some refactoring: BrodgeConnector does not depends now from BluetoothManager; CausticDevicesManager.Receiver prepared for direct commands for android device support
2016-10-13 [Android] Fix for prev commit. Files added, little refactoring
2016-10-14 [Android] RCSP streams dispatch refactored, now should use RCSPOperationDispatcher
2016-10-16 [docs] Documents dirs structure fix
2016-10-16 [site] submodule now use https
2016-10-17 [site] WIP
2016-10-18 [site] Some design improvement
2016-10-19 [android] [firmware] Work on statistics; some debug output improvements - control header added
2016-10-21 [android] device pop data timeout added, now disconnected device treated coorrectly in settings editor
2016-10-22 [site] RCSP doc improved; design fixes
2016-10-23 [site] Google verification code added
2016-10-24 [site] Minor spell fix
2016-10-27 [build] -std=gnu11 flag added for c compiler
2016-10-28 [site] build doc fix
2016-11-03 [PCB[ Rifle mono silk in process
2016-11-04 [site] RCSP descr improved
2016-11-06 [pcb] Rifle monolithic panelized done and send to factory
2016-11-10 [firmware] UART HAL refactoring
2016-11-11 [firmware] Bluetooth auto-configuration works. TODO: add editable name/password and refactor some points
2016-11-12 [firmware] Bluetooth PIN configuration
2016-11-27 [firmware] Fix for pinout checking function of head sensor; vibro engine enabled for any data signal to killzone
2016-11-28 [PCB] Sensor module for tube
2016-11-29 [PCB] Boards group for latest HS and tube sensors. Python script for boards outline fixing
2016-11-30 [PCB] Tube sensor connector component added
2016-12-02 [firmware] newlib uses USB debug output and file reading works
2016-12-04 [firmware] New uiversal device low-level code ready to migrate main project
2016-12-09 [firmware] SDCard mutexes added, but head sensor unstable
2016-12-09 [firmware] FreeRTOS update seems to be successful, bt bridge works
2016-12-10 [firmware] Head sensors seems stable except of file writing
2016-12-10 [firmware] Directories structure improved
2016-12-13 [firmware] Now only one playerId is in game. RCSP headers renamed
2016-12-17 [firmware] Network client layer integration done. I cannot reproduce hard fault, may be IRQ priority=4 for SPI fixed. By the way fault handler improved
2016-12-20 [firmware] Broadcast for not-bluetooth-bridge added, corresponding fix for Android
2016-12-23 [firmware] Display works
2016-12-24 text output works but with artifacts sometimes
2016-12-25 [site] .pdf schematics added
2017-01-07 [android] Moved core RCSProtocol source code into "rcspcore" module inside CausticLaserTagController project, created LasertagClientApp project with "rcspcore" as dependency
2017-01-08 [android] Enhanced client app compatibility with API 16
2017-01-10 [android] Added BT connection monitor in client app's main activity, disconnect button in action bar
2017-01-11 [firmware] Added latitude and longitude to head sensor Config parameters (location reporting)
2017-01-11 [android] Fixed settings back button bug and player list table separator bug
2017-01-12 [firmware, android] Fixed head sensor RGB LED pinout, added player position discovery in client Android app
2017-01-12 [android] Added Google Maps fragment to the HUD screen, custom team-based markers
2017-01-13 [firmware] Hard fault handler improved. Minor bluetooth bridge fixes. Hard Faults do not take place if m_workerToBluetooth disabled
2017-01-14 [android] Fixed back button behavior in Settings
2017-01-15 [android] Added basic BT stress testing to the controller app
2017-01-15 [android] Basic stats display in map screen works
2017-01-15 [android] Added scores table with auto-updating (same pattern ad in MapFragment)
2017-01-17 [firmware] Build fix for prev commit
2017-01-25 Some refactoring; new IR system in process
2017-01-30 Illumination for respawn works
2017-02-04 PWM support for internal illumination points added, ST copyrights updated
2017-02-04 Sensors initialization from file works
2017-02-04 new/delete protected by mutexes. Fix for death illumination
2017-02-11 Fixes for multiply receivers case
2017-02-12 Key sequence seems not breaking reloading
2017-02-17 new/delete mutexes changed to critical sections to prevend blocking in interrupt
2017-02-17 WIP, some improvements. Android app threading fixed
2017-02-19 Free heap and thread id output added to every debug message. System stability is at leat >14min if heap is enough.
2017-02-26 Rifle mono board 1.1: capacitor near PAM; I2C pull-up; Laser TTL output
2017-03-10 Grouped board with rifle and smart sensors fixed
2017-03-18 IR data receiving works
2017-04-08 Smart sensor animation reset support, ssp timings improved
2017-05-06 [firmware] Fix for heartbeat: died cannot shot. Initial sensors blink enabled for smart sensors. Little refactoring
2017-05-14 [Android] Refactoring; Nested classes moved out, packages queue for bluetooth added
2017-06-01 [firmware] Only damaged sensors blinks when shot
2017-06-21 [firmware] Audio interruptions fix; some other fixes
2017-06-25 [android] Projects restructured: rcspcore is java module (not android), androidshared is android-specific thing. Controller app removed temporary
2017-10-10 [firmware] INetworkLayer interface added, Network Layer is not singleton now
2017-10-13 [firmware] AnyDeviceBase segregation
2017-10-24 [firmware] newlib.c now supports fatfs, so files should be accessed via fopen(...); RCSP push/pull/call renamed to this; Some code simplification for unit tests; unit tests (not working); Some forgot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
2017-10-26 [firmware] Wav player works with stdio.h
2017-10-30 _lseek function implemented for newlib
2017-11-02 [firmware] RCSPAggregator refactoring: work with Buffer, unit tests for it. Some other refactoring and renaming
2017-11-09 [firmware] RCSPAggregator::verify and ::split added with tests
2017-11-12 [firmware] New implemetation of RCSPStream works. Network layers initialization moved to constructors
2017-11-14 [firmware] Some interface segregation, renaming and pinters to reference replacements
2017-11-27 [Android] Projects re-created, API 18
2017-12-09 [Android] Navigation bar wroks, bluetooth connection works
2017-12-26 [Android] Devices-to-edit list works
2018-01-05 [Android] Fix for focuse loosing when editing parameters. Not used classes removed
2018-01-09 [Android] Statistics auto updating works, devices count update speed increased [firmware] reset player code fixed, some unused parameters removed
2018-01-11 [firmware] Fix in network layer: the bug was that oly first local receiver gets a package. It appears when i.e. broadcast for all is sended by HS
