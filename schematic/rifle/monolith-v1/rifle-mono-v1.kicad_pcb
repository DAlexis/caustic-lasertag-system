# Repository DAlexis/caustic-lasertag-system (continued)

## KiCad design schematic/head-sensor/head-sensor-shield-lite-rev1/head-sensor-shield.kicad_pcb

Parts:
BT1: BATTERY
C1: 1uF
C2, C3: 100uF
C4: 0.1uF
C5: 4.7uF
D1: LED
J1: USB
K1: Power
P3: MCU1
P4: USART1
P6: MCU2
P8: NRF24L01
P9: Zone1
Q1: MOSFET_P
Q2, Q3, Q4, Q5: MOS_N
R1, R2: 10k
R3: 470
R4: 1.5k
R6: 2k
U1: NCP551
U2: USBLC6-4
U3: MCP73831

Connections:
+3.3V: C3.1, P3.2, P8.2 (VCC), P9.3 (+3.3), R4.2, U1.5 (Out)
+BATT: BT1.1 (+), P3.3
GND: BT1.2 (-), C1.2, C2.2, C3.2, C4.1, J1.4 (GND), K1.1, P3.1, P4.1, P8.1 (GND), P9.1 (GND), Q1.G, Q2.S, Q3.S, Q4.S, Q5.S, R1.1, R6.1, U1.2 (GND), U2.2 (GND), U3.2 (Vss)
unnamed: K1.3, Q1.D
unnamed: P9.7 (B), Q4.D
unnamed: P3.8, P9.4 (Signal)
unnamed: P9.5 (R), Q2.D
unnamed: P9.6 (G), Q3.D
unnamed: P3.18, Q4.G
unnamed: P3.15, Q3.G
unnamed: P3.14, Q2.G
unnamed: P6.5, P8.7 (MISO)
unnamed: P6.3, P8.4 (CSN)
unnamed: P6.4, P8.5 (SCK)
unnamed: P6.6, P8.6 (MOSI)
unnamed: P6.19, P8.8 (IRQ)
unnamed: P6.18, P8.3 (CE)
unnamed: J1.2 (D-), P6.11, U2.6 (I/O4)
unnamed: J1.3 (D+), P6.12, R4.1, U2.4 (I/O3)
unnamed: C5.1, K1.2 (PM), U3.3 (Vbat)
unnamed: C5.2, R6.2, U3.5 (PROG)
unnamed: P4.2 (PM), P6.9
unnamed: P3.4, Q5.G
unnamed: P9.8 (Vibro), Q5.D
unnamed: R3.2, U3.1 (STAT)
unnamed: D1.2 (K), R3.1
unnamed: D1.1 (A), J1.1 (Vbus), U2.5 (Vbus), U3.4 (Vdd)
unnamed: C4.2, P3.16, R1.2, R2.2
VCC: C1.1, C2.1, P9.2 (+Vcc), Q1.S, R2.1, U1.1 (In), U1.3 (Enable)

Board: 2 copper layers, 46.1 x 26.0 mm, 28 parts (9 on the bottom side), 29 nets.

Other parts of the board:
1PIN: P***; 1pin

## KiCad design schematic/sensor-module/sensor-module-idc-circle-lw/sensor-module.kicad_pcb

Parts:
P1: SENSOR_CONNECTOR
P2: VibroEngine
R1, R2, R3, R4, R5, R6, R7: R
U1, U2: RGB-LED
U3, U4: TSOP4856

Connections:
+3.3V: P1.3 (+3.3), U3.3 (V+), U4.3 (V+)
+BATT: P1.2 (+Vcc), R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.2
GND: P1.1 (GND), U3.2 (GND), U4.2 (GND)
unnamed: P1.4 (Signal), U3.1 (OUT), U4.1 (OUT)
unnamed: R6.2, U2.6 (B+)
unnamed: R5.2, U2.5 (G+)
unnamed: R4.2, U2.4 (R+)
unnamed: P1.8 (Vibro), P2.2 (PM)
unnamed: P2.1, R7.1
unnamed: P1.5 (R), U1.3 (R-), U2.3 (R-)
unnamed: P1.6 (G), U1.2 (G-), U2.2 (G-)
unnamed: P1.7 (B), U1.1 (B-), U2.1 (B-)
unnamed: R1.2, U1.4 (R+)
unnamed: R3.2, U1.6 (B+)
unnamed: R2.2, U1.5 (G+)

Board: 2 copper layers, 29.5 x 29.5 mm, 15 parts (8 on the bottom side), 15 nets.

Other parts of the board:
1PIN, 1PIN#2: P***; 1pin

## KiCad design schematic/connectors/usb-connector-type-b/usb-connector.kicad_pcb

Parts:
J1: USB
P1: CONN_4

Connections:
unnamed: J1.4 (GND), P1.1
unnamed: J1.1 (Vbus), P1.4
unnamed: J1.3 (D+), P1.3
unnamed: J1.2 (D-), P1.2

Board: 2 copper layers, 25.7 x 13.5 mm, 4 parts (0 on the bottom side), 4 nets.

Other parts of the board:
1PIN, 1PIN#2: P***; 1pin

## KiCad design schematic/mcu-module/mcu-module-rev1/mcu-module.kicad_pcb

Parts:
C1, C6: 100uF
C2, C3, C4, C5: 20pF
C7, C8, C9, C10: 0.1uF
FB1: FILTER
P1: MCU1
P2: MICROSD-SDIO-CD
P3: SWD
P4: MCU2
R1, R2, R3, R4, R5: 47k
R6: 100
U1: STM32F103RE; LQFP64
X1: 32768Hz
X2: 8MHz

Connections:
+3.3V: C1.1, C7.1, C8.1, C9.1, C10.1, FB1.2, P2.4 (Vdd), R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, U1.19 (VDD), U1.32 (VDD), U1.48 (VDD), U1.64 (VDD)
GND: C1.2, C2.1, C3.1, C4.1, C5.1, C6.2, C7.2, C8.2, C9.2, C10.2, P1.1, P2.6 (GND), P2.CD1, P3.1, U1.12 (VSSA), U1.18 (VSS), U1.31 (VSS), U1.47 (VSS), U1.63 (VSS)
unnamed: P1.18, U1.26 (ADC12_IN8/TIM3_CH3/TIM8_CH2N/PB0)
unnamed: P1.20, U1.28 (BOOT1/PB2)
unnamed: P1.19, U1.27 (ADC12_IN9/TIM3_CH4/TIM8_CH3N/PB1)
unnamed: P1.17, U1.25 (PC5/ADC12_IN15)
unnamed: P1.16, U1.24 (PC4/ADC12_IN14)
unnamed: P4.9, U1.42 (USART1_TX/TIM1_CH2/PA9)
unnamed: P4.8, U1.41 (USART1_CK/TIM1_CH1/MCO/PA8)
unnamed: P4.7, U1.37 (PC6/I2S2_MCK/TIM8_CH1/SDIO_D6)
unnamed: P4.6, U1.36 (SPI2_MOSI/I2S2_SD/TIM1_CH3N/PB15)
unnamed: P4.5, U1.35 (SPI2_MISO/TIM1_CH2N/USART3_RTS/PB14)
unnamed: P4.4, U1.34 (SPI2_SCK/I2S2_CK/USART3_CTS/TIM1_CH1N/P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)
unnamed: P4.3, U1.33 (SPI2_NSS/I2S2_WS/I2C2_SMBA/USART3_CK/TI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)
unnamed: P4.2, U1.30 (I2C2_SDA/USART3_RX/PB11)
unnamed: P4.1, U1.29 (I2C2_SCL/USART3_TX/PB10)
unnamed: P1.6, U1.10 (PC2/ADC123_IN12)
unnamed: P1.10, U1.16 (USART2_TX/TIM5_CH3/ADC123_IN2/TIM2_CH3/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)
unnamed: P1.9, U1.15 (USART2_RTS/ADC123_IN1/TIM5_CH2/TIM2_CH2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)
unnamed: P1.8, U1.14 (WKUP/USART2_CTS/ADC123_IN0/TIM2_CH1_ETR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)
unnamed: P1.7, U1.11 (PC3/ADC123_IN13)
unnamed: P1.5, U1.9 (PC1/ADC123_IN11)
unnamed: P1.4, U1.8 (PC0/ADC123_IN10)
unnamed: P1.3, U1.1 (VBAT)
unnamed: P1.14, U1.22 (SPI1_MISO/TIM8_BKIN/ADC12_IN6/TIM3_CH1/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)
unnamed: P1.15, U1.23 (SPI1_MOSI/TIM8_CH1N/ADC12_IN7/TIM3_CH2/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)
unnamed: P1.13, U1.21 (SPI1_SCK/DAC_OUT2/ADC12_IN5/PA5)
unnamed: P1.11, U1.17 (USART2_RX/TIM5_CH4/ADC123_IN3/TIM2_CH4/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)
unnamed: P1.12, U1.20 (SPI1_NSS/USART2_CK/DAC_OUT1/ADC12_IN4/P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)
unnamed: FB1.1, P1.2
unnamed: P4.19, U1.61 (TIM4_CH3/SDIO_D4/PB8)
unnamed: P4.18, U1.59 (I2C1_SDA/TIM4_CH2/PB7)
unnamed: P4.17, U1.58 (I2C1_SCL/TIM4_CH1/PB6)
unnamed: P4.16, U1.57 (I2C1_SMBA/SPI3_MOSI/I2S3_CD/PB5)
unnamed: P4.13, U1.50 (JTDI/SPI3_NSS/I2S3_WS/PA15)
unnamed: P4.12, U1.45 (USART1_RTS/USBDP/CAN_TX/TIM1_ETR/PA11)
unnamed: P4.11, U1.44 (USART1_CTS/USBDM/CAN_RX/TIM1_CH4/PA11)
unnamed: P4.10, U1.43 (USART1_RX/TIM1_CH3/PA10)
unnamed: P3.2, U1.7 (~NRST)
unnamed: P4.15, U1.56 (NJTRST/SPI3_MISO/PB4)
unnamed: P4.20, U1.62 (TIM4_CH4/SDIO_D5/PB9)
unnamed: P4.14, U1.55 (JTDO/SPI3_SCK/I2S3_CK/PB3)
unnamed: P3.3, U1.46 (JTMS/SWDIO/PA13)
unnamed: P3.4, U1.49 (JTCK/SWCLK/PA14)
unnamed: C2.2, U1.3 (PC14/OSC32_IN), X1.1
unnamed: C3.2, U1.4 (PC15/OSC32_OUT), X1.2
unnamed: P2.CD2, U1.38 (PC7/I2S3_MCK/TIM8_CH2/SDIO_D7)
unnamed: C6.1, R6.1, U1.13 (VDDA)
unnamed: C4.2, U1.5 (PD0/OSC_IN), X2.2
unnamed: P2.3 (CMD), R5.1, U1.54 (PD2/TIM3_ETR/UART5_RX/SDIO_CMD)
unnamed: P2.5 (CLK), U1.53 (PC12/UART5_TX/SDIO_CK)
unnamed: C5.2, U1.6 (PD1/OSC_OUT), X2.1
unnamed: P2.7 (DAT0), R4.1, U1.39 (PC8/TIM8_CH3/SDIO_D0)
unnamed: P2.8 (DAT1/nIRQ), R3.1, U1.40 (PC9/TIM8_CH4/SDIO_D1)
unnamed: P2.1 (DAT2), R2.1, U1.51 (PC10/UART4_TX/SDIO_D2)
unnamed: P2.2 (DAT3), R1.1, U1.52 (PC11/UART4_RX/SDIO_D3)

Board: 2 copper layers, 46.2 x 26.0 mm, 24 parts (12 on the bottom side), 56 nets.

## KiCad design schematic/bridge/bluetooth-bridge/bluetooth-bridge.kicad_pcb

Parts:
C1, C2, C3, C5: 0.1uF
C4, C6, C7: 100uF
C8: 0.1
C9: 47uF
D1, D2, D3: LED
FB1, FB2: FILTER
K1: Battery
P1: MCU1
P2: USART1
P3: USB
P4: MCU2
P5: EXTENSION-CONNECTOR
P6: NRF24L01
Q1: MOSFET_P
R1, R2, R3: 10k
R4, R5, R7: 470
R6: 1.5k
R8: 2k
U1: ITEAD_HC-05
U2: NCP551
U3: USBLC6-4
U4: MCP73831

Connections:
+3.3V: C5.1, C6.1, FB1.1, FB2.2, P1.2, P5.7, R6.1, U2.5 (Out)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, D1.2 (K), D2.2 (K), K1.1, P1.1, P2.1, P3.1, P5.6, P6.1 (GND), Q1.G, R2.2, R3.2, R8.1, U1.13 (GND), U1.21 (GND), U1.22 (GND), U2.2 (GND), U3.2 (GND), U4.2 (Vss)
unnamed: P4.13, P5.1
unnamed: P4.14, P5.2
unnamed: P4.16, P5.3
unnamed: P4.15, P5.4
unnamed: P4.17, P5.5
unnamed: P4.1, P5.9
unnamed: P4.2, P5.10
unnamed: P4.19, P6.8 (IRQ)
unnamed: P4.18, P6.3 (CE)
unnamed: P4.3, P6.4 (CSN)
unnamed: P4.4, P6.5 (SCK)
unnamed: P4.6, P6.6 (MOSI)
unnamed: P4.5, P6.7 (MISO)
unnamed: P2.2 (PM), P4.9
unnamed: P4.20, P5.8
unnamed: P3.2, P4.11, U3.6 (I/O4)
unnamed: P3.3, P4.12, R6.2, U3.4 (I/O3)
unnamed: D2.1 (A), R5.2
unnamed: R5.1, U1.32 (PIO9)
unnamed: D1.1 (A), R4.2
unnamed: R4.1, U1.24 (PIO1)
unnamed: P1.11, U1.1 (UART_TX)
unnamed: P1.10, U1.2 (UART_RX)
unnamed: R3.1, U1.26 (PIO3), U1.34 (PIO11)
unnamed: C7.1, C8.1, FB2.1, P6.2 (VCC)
unnamed: C3.1, C4.1, FB1.2, U1.12 (VCC)
unnamed: C9.1, K1.2 (PM), U4.3 (Vbat)
unnamed: K1.3, Q1.D
unnamed: R7.1, U4.1 (STAT)
unnamed: C9.2, R8.2, U4.5 (PROG)
unnamed: D3.2 (K), R7.2
unnamed: D3.1 (A), P3.4, U3.5 (Vbus), U4.4 (Vdd)
unnamed: C1.1, Q1.S, R1.1, U2.1 (In), U2.3 (Enable)
unnamed: C2.1, P1.16, R1.2, R2.1
